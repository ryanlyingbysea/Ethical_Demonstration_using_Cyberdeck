options:
  parameters:
    generate_options: qt_gui
    id: FM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: bb_db
  id: variable_qtgui_range
  parameters:
    label: bb_db
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    start: 90e3
    step: '10'
    stop: 120e3
    value: '107600'
  states: {}
- name: if_db
  id: variable_qtgui_range
  parameters:
    label: if_db
    start: '0'
    step: '1'
    stop: '100'
    value: '89'
  states: {}
- name: rf_db
  id: variable_qtgui_range
  parameters:
    label: rf_db
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: volume
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: 2e6
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 107.6e6
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 107.6e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 190e3
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    fbw: '100e-3'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    fbw: '100e-3'
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: bb_db
    freq0: freq*1000
    gain0: rf_db
    gain_mode0: 'False'
    if_gain0: if_db
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
